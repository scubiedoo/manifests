## Config.in
```kconfig
#
# For a description of the syntax of this configuration file,
# see scripts/config-language.txt.
#

menu "Cubiuntu Menuconfig"

source config/cubieboard.in

endmenu
```
